# Keil uVision project PD_TEST_S5.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC240VE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: PD_TEST_S5 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --no-multibyte-chars
  c include: ..\Library\Device\Nuvoton\NUC230_240\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group User
    ../src/: main.c uart_process.c bsp.c can_drv.c list.c
  group Library
    ../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c uart.c pdma.c can.c adc.c spi.c pwm.c scuart.c wdt.c
